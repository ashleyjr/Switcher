# Keil uVision project Switcher.uvproj, settings and files
target Switcher (MCS-51)
  device: C8051F850-GU/IU Silicon Labs
  cpu: IRAM(0x00-0xFF) XRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(25000000)
  output: Switcher +hex
  c flags: Optimize=8
  c include: .\Inc
  group Inc
    ./Inc/: ABSACC.H ASSERT.H C8051F850.INC C8051F850_defs.h compiler_defs.h CTYPE.H endian.h ERRNO.H FLOAT.H InitDevice.h INTRINS.H LIMITS.H MATH.H REG51.H REG52.H RTX51TNY.H SETJMP.H SI_C8051F850_Defs.h SI_C8051F850_Defs.inc SI_C8051F850_Register_Enums.h SI_C8051F850_Register_Enums.inc si_toolchain.h SROM.H STDARG.H stdbool.h STDDEF.H stdint.h STDIO.H STDLIB.H STRING.H Pid.h Uart.h Adc.h
  group Src
    ./Src/: InitDevice.c main.c Pid.c Interrupts.c Uart.c Adc.c
